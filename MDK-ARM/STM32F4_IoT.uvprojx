# Keil uVision project STM32F4_IoT.uvprojx, settings and files
target STM32F4_IoT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4_IoT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=2 v6LangP=2 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Include;                 ../Inc;                 ../Drivers/STM32F4xx_HAL_Driver/Inc;                 ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                 ../Drivers/CMSIS/Include;                 .\User Module\Peripheral\inc;                 .\User Module\Middle Application Layer\inc;                 ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Peripheral
    ./User Module/Peripheral/src/: bsp_led.c bsp_eeprom.c bsp_spi_flash.c bsp_key.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
software components: CMSIS:CORE 5.1.1, Compiler:Event Recorder 1.4.0
